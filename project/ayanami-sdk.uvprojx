# Keil uVision project ayanami-sdk.uvprojx, settings and files
target ayanami-SDK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ayanami-sdk
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..\..\..\..;C:\ti\TivaWare_C_Series-2.2.0.295;..\libraries\ayanami_driver;..\libraries\ayanami_device;..\libraries\ayanami_common;.\User;..\libraries\bsxlite
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Objects\ayanami-sdk.sct
  link misc: --entry Reset_Handler
  group User
    ./User/: main.c isr.c
    ../libraries/tiva/startup/: startup_rvmdk.S
  group tiva_driverlib
    ../libraries/tiva/driverlib/rvmdk/: driverlib.lib
  group tiva_utils
    ../libraries/tiva/utils/: cpu_usage.c eeprom_pb.c flash_pb.c isqrt.c random.c ringbuf.c sine.c smbus.c softi2c.c softssi.c softuart.c spi_flash.c uartstdio.c ustdlib.c
  group ayanami_device
    ../libraries/ayanami_device/: aya_device_bmi088.c aya_device_ips130.c aya_device_infrared.c
  group ayanami_driver
    ../libraries/ayanami_driver/: aya_driver_adc.c aya_driver_gpio.c aya_driver_i2c.c aya_driver_pwm.c aya_driver_spi.c aya_driver_systick.c aya_driver_timer.c aya_driver_uart.c
  group bsxlite
    ../libraries/bsxlite/: bsxlite_interface.h libalgobsx.lib
software components: CMSIS:CORE 5.2.0
